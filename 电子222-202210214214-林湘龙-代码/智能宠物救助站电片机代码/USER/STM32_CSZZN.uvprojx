# Keil uVision project STM32_CSZZN.uvprojx, settings and files
target CSZZN (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_CSZZN +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE\DHT11;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\TFTLCD;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\SYSTEM\timer;..\SYSTEM\adc;..\SYSTEM\flash;..\HARDWARE\STEPMOTOR;..\HARDWARE\BUMP;..\HARDWARE\MODULES;..\HARDWARE\ESP8266;..\HARDWARE\HW;..\HARDWARE\HX711;..\HARDWARE\RELAY;..\HARDWARE\WATER;..\SYSTEM\usart2;..\HARDWARE\Common;..\HARDWARE\RTC;..\SYSTEM\usart3;..\SYSTEM\iwdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TFTLCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/STEPMOTOR/: stepmotor.c
    ../HARDWARE/BUMP/: bump.c
    ../HARDWARE/MODULES/: Modules.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/HW/: HW.c
    ../HARDWARE/HX711/: hx711.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/WATER/: water.c
    ../HARDWARE/Common/: Common.c
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/timer/: TIM2.c TIM3.c
    ../SYSTEM/adc/: adcx.c
    ../SYSTEM/flash/: Flash.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/usart3/: usart3.c
    ../SYSTEM/iwdg/: iwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
